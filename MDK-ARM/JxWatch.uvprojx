# Keil uVision project JxWatch.uvprojx, settings and files
target JxWatch (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: JxWatch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32L431xx,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;RTE/_JxWatch;../Libraries/FreeRTOS-Kernel/include;../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F;../Libraries/lvgl/src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group ../LIBRARIES/LVGL/SRC
    ../Libraries/lvgl/src/: lv_init.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/WIN
    ../Libraries/lvgl/src/widgets/win/: lv_win.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/TILEVIEW
    ../Libraries/lvgl/src/widgets/tileview/: lv_tileview.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/TEXTAREA
    ../Libraries/lvgl/src/widgets/textarea/: lv_textarea.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/TABVIEW
    ../Libraries/lvgl/src/widgets/tabview/: lv_tabview.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/TABLE
    ../Libraries/lvgl/src/widgets/table/: lv_table.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SWITCH
    ../Libraries/lvgl/src/widgets/switch/: lv_switch.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SPINNER
    ../Libraries/lvgl/src/widgets/spinner/: lv_spinner.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SPINBOX
    ../Libraries/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SPAN
    ../Libraries/lvgl/src/widgets/span/: lv_span.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SLIDER
    ../Libraries/lvgl/src/widgets/slider/: lv_slider.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/SCALE
    ../Libraries/lvgl/src/widgets/scale/: lv_scale.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/ROLLER
    ../Libraries/lvgl/src/widgets/roller/: lv_roller.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/OBJX_TEMPL
    ../Libraries/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/MSGBOX
    ../Libraries/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/MENU
    ../Libraries/lvgl/src/widgets/menu/: lv_menu.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/LIST
    ../Libraries/lvgl/src/widgets/list/: lv_list.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/LINE
    ../Libraries/lvgl/src/widgets/line/: lv_line.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/LED
    ../Libraries/lvgl/src/widgets/led/: lv_led.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/LABEL
    ../Libraries/lvgl/src/widgets/label/: lv_label.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/KEYBOARD
    ../Libraries/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/IMAGEBUTTON
    ../Libraries/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/IMAGE
    ../Libraries/lvgl/src/widgets/image/: lv_image.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/DROPDOWN
    ../Libraries/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/CHECKBOX
    ../Libraries/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/CHART
    ../Libraries/lvgl/src/widgets/chart/: lv_chart.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/CANVAS
    ../Libraries/lvgl/src/widgets/canvas/: lv_canvas.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/CALENDAR
    ../Libraries/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/BUTTONMATRIX
    ../Libraries/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/BUTTON
    ../Libraries/lvgl/src/widgets/button/: lv_button.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/BAR
    ../Libraries/lvgl/src/widgets/bar/: lv_bar.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/ARC
    ../Libraries/lvgl/src/widgets/arc/: lv_arc.c
  group ../LIBRARIES/LVGL/SRC/WIDGETS/ANIMIMAGE
    ../Libraries/lvgl/src/widgets/animimage/: lv_animimage.c
  group ../LIBRARIES/LVGL/SRC/TICK
    ../Libraries/lvgl/src/tick/: lv_tick.c
  group ../LIBRARIES/LVGL/SRC/THEMES
    ../Libraries/lvgl/src/themes/: lv_theme.c
  group ../LIBRARIES/LVGL/SRC/THEMES/SIMPLE
    ../Libraries/lvgl/src/themes/simple/: lv_theme_simple.c
  group ../LIBRARIES/LVGL/SRC/THEMES/MONO
    ../Libraries/lvgl/src/themes/mono/: lv_theme_mono.c
  group ../LIBRARIES/LVGL/SRC/THEMES/DEFAULT
    ../Libraries/lvgl/src/themes/default/: lv_theme_default.c
  group ../LIBRARIES/LVGL/SRC/STDLIB
    ../Libraries/lvgl/src/stdlib/: lv_mem.c
  group ../LIBRARIES/LVGL/SRC/STDLIB/RTTHREAD
    ../Libraries/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group ../LIBRARIES/LVGL/SRC/STDLIB/MICROPYTHON
    ../Libraries/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group ../LIBRARIES/LVGL/SRC/STDLIB/CLIB
    ../Libraries/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group ../LIBRARIES/LVGL/SRC/STDLIB/BUILTIN
    ../Libraries/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/VG_LITE_TVG
    ../Libraries/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
  group ../LIBRARIES/LVGL/SRC/OTHERS/SYSMON
    ../Libraries/lvgl/src/others/sysmon/: lv_sysmon.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/SNAPSHOT
    ../Libraries/lvgl/src/others/snapshot/: lv_snapshot.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/OBSERVER
    ../Libraries/lvgl/src/others/observer/: lv_observer.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/MONKEY
    ../Libraries/lvgl/src/others/monkey/: lv_monkey.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/IMGFONT
    ../Libraries/lvgl/src/others/imgfont/: lv_imgfont.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/IME
    ../Libraries/lvgl/src/others/ime/: lv_ime_pinyin.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/GRIDNAV
    ../Libraries/lvgl/src/others/gridnav/: lv_gridnav.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/FRAGMENT
    ../Libraries/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group ../LIBRARIES/LVGL/SRC/OTHERS/FILE_EXPLORER
    ../Libraries/lvgl/src/others/file_explorer/: lv_file_explorer.c
  group ../LIBRARIES/LVGL/SRC/OSAL
    ../Libraries/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group ../LIBRARIES/LVGL/SRC/MISC
    ../Libraries/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group ../LIBRARIES/LVGL/SRC/MISC/CACHE
    ../Libraries/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_image_cache.c _lv_cache_lru_rb.c
  group ../LIBRARIES/LVGL/SRC/LIBS/TJPGD
    ../Libraries/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group ../LIBRARIES/LVGL/SRC/LIBS/TINY_TTF
    ../Libraries/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group ../LIBRARIES/LVGL/SRC/LIBS/THORVG
    ../Libraries/lvgl/src/libs/thorvg/: tvgAnimation.cpp tvgBezier.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgInitializer.cpp tvgLoader.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgXmlParser.cpp
  group ../LIBRARIES/LVGL/SRC/LIBS/RLOTTIE
    ../Libraries/lvgl/src/libs/rlottie/: lv_rlottie.c
  group ../LIBRARIES/LVGL/SRC/LIBS/RLE
    ../Libraries/lvgl/src/libs/rle/: lv_rle.c
  group ../LIBRARIES/LVGL/SRC/LIBS/QRCODE
    ../Libraries/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group ../LIBRARIES/LVGL/SRC/LIBS/LZ4
    ../Libraries/lvgl/src/libs/lz4/: lz4.c
  group ../LIBRARIES/LVGL/SRC/LIBS/LODEPNG
    ../Libraries/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group ../LIBRARIES/LVGL/SRC/LIBS/LIBPNG
    ../Libraries/lvgl/src/libs/libpng/: lv_libpng.c
  group ../LIBRARIES/LVGL/SRC/LIBS/LIBJPEG_TURBO
    ../Libraries/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group ../LIBRARIES/LVGL/SRC/LIBS/GIF
    ../Libraries/lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group ../LIBRARIES/LVGL/SRC/LIBS/FSDRV
    ../Libraries/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group ../LIBRARIES/LVGL/SRC/LIBS/FREETYPE
    ../Libraries/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group ../LIBRARIES/LVGL/SRC/LIBS/FFMPEG
    ../Libraries/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group ../LIBRARIES/LVGL/SRC/LIBS/BMP
    ../Libraries/lvgl/src/libs/bmp/: lv_bmp.c
  group ../LIBRARIES/LVGL/SRC/LIBS/BIN_DECODER
    ../Libraries/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group ../LIBRARIES/LVGL/SRC/LIBS/BARCODE
    ../Libraries/lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group ../LIBRARIES/LVGL/SRC/LAYOUTS
    ../Libraries/lvgl/src/layouts/: lv_layout.c
  group ../LIBRARIES/LVGL/SRC/LAYOUTS/GRID
    ../Libraries/lvgl/src/layouts/grid/: lv_grid.c
  group ../LIBRARIES/LVGL/SRC/LAYOUTS/FLEX
    ../Libraries/lvgl/src/layouts/flex/: lv_flex.c
  group ../LIBRARIES/LVGL/SRC/INDEV
    ../Libraries/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group ../LIBRARIES/LVGL/SRC/FONT
    ../Libraries/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/X11
    ../Libraries/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/WINDOWS
    ../Libraries/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/SDL
    ../Libraries/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/NUTTX
    ../Libraries/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/EVDEV
    ../Libraries/lvgl/src/drivers/evdev/: lv_evdev.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/TFT_ESPI
    ../Libraries/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/ST7796
    ../Libraries/lvgl/src/drivers/display/st7796/: lv_st7796.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/ST7789
    ../Libraries/lvgl/src/drivers/display/st7789/: lv_st7789.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/ST7735
    ../Libraries/lvgl/src/drivers/display/st7735/: lv_st7735.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/LCD
    ../Libraries/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/ILI9341
    ../Libraries/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/FB
    ../Libraries/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
  group ../LIBRARIES/LVGL/SRC/DRIVERS/DISPLAY/DRM
    ../Libraries/lvgl/src/drivers/display/drm/: lv_linux_drm.c
  group ../LIBRARIES/LVGL/SRC/DRAW
    ../Libraries/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_buf.c lv_image_decoder.c
  group ../LIBRARIES/LVGL/SRC/DRAW/VG_LITE
    ../Libraries/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_utils.c
  group ../LIBRARIES/LVGL/SRC/DRAW/SW
    ../Libraries/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
  group ../LIBRARIES/LVGL/SRC/DRAW/SW/BLEND
    ../Libraries/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group ../LIBRARIES/LVGL/SRC/DRAW/SW/BLEND/NEON
    ../Libraries/lvgl/src/draw/sw/blend/neon/: lv_blend_neon.S
  group ../LIBRARIES/LVGL/SRC/DRAW/SDL
    ../Libraries/lvgl/src/draw/sdl/: lv_draw_sdl.c
  group ../LIBRARIES/LVGL/SRC/DRAW/RENESAS/DAVE2D
    ../Libraries/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
  group ../LIBRARIES/LVGL/SRC/DRAW/NXP/VGLITE
    ../Libraries/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
  group ../LIBRARIES/LVGL/SRC/DRAW/NXP/PXP
    ../Libraries/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
  group ../LIBRARIES/LVGL/SRC/DISPLAY
    ../Libraries/lvgl/src/display/: lv_display.c
  group ../LIBRARIES/LVGL/SRC/CORE
    ../Libraries/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group ../APP/TASKS
    ../App/Tasks/: task_screen.c task_test.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Application/User/Core
    ../Core/Src/: lv_port_lcd_stm32.c main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group ../LIBRARIES/FREERTOS-KERNEL
    ../Libraries/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ../LIBRARIES/FREERTOS-KERNEL/EXAMPLES/CMAKE_EXAMPLE
    ../Libraries/FreeRTOS-Kernel/examples/cmake_example/: main.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/GCC/ARM_CM23
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/GCC/ARM_CM23/: mpu_wrappers_v2_asm.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/GCC/ARM_CM23_NTZ
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/GCC/ARM_CM23_NTZ/: mpu_wrappers_v2_asm.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/GCC/ARM_CM33
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33/: mpu_wrappers_v2_asm.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/GCC/ARM_CM33_NTZ
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: mpu_wrappers_v2_asm.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/IAR/ARM_CM23
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/IAR/ARM_CM23/: mpu_wrappers_v2_asm.S portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/IAR/ARM_CM23_NTZ
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/IAR/ARM_CM23_NTZ/: mpu_wrappers_v2_asm.S portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/IAR/ARM_CM33
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/IAR/ARM_CM33/: mpu_wrappers_v2_asm.S portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/NON_SECURE/PORTABLE/IAR/ARM_CM33_NTZ
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/non_secure/portable/IAR/ARM_CM33_NTZ/: mpu_wrappers_v2_asm.S portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/CONTEXT
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/context/: secure_context.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/CONTEXT/PORTABLE/GCC/ARM_CM23
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/context/portable/GCC/ARM_CM23/: secure_context_port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/CONTEXT/PORTABLE/GCC/ARM_CM33
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/context/portable/GCC/ARM_CM33/: secure_context_port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/CONTEXT/PORTABLE/IAR/ARM_CM23
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/context/portable/IAR/ARM_CM23/: secure_context_port_asm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/CONTEXT/PORTABLE/IAR/ARM_CM33
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/context/portable/IAR/ARM_CM33/: secure_context_port_asm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/HEAP
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/heap/: secure_heap.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ARMV8M/SECURE/INIT
    ../Libraries/FreeRTOS-Kernel/portable/ARMv8M/secure/init/: secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/BCC/16BITDOS/COMMON
    ../Libraries/FreeRTOS-Kernel/portable/BCC/16BitDOS/common/: portcomn.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/BCC/16BITDOS/FLSH186
    ../Libraries/FreeRTOS-Kernel/portable/BCC/16BitDOS/Flsh186/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/BCC/16BITDOS/PC
    ../Libraries/FreeRTOS-Kernel/portable/BCC/16BitDOS/PC/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CCS/ARM_CM3
    ../Libraries/FreeRTOS-Kernel/portable/CCS/ARM_CM3/: port.c portasm.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CCS/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/CCS/ARM_CM4F/: port.c portasm.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CCS/ARM_CORTEX-R4
    ../Libraries/FreeRTOS-Kernel/portable/CCS/ARM_Cortex-R4/: port.c portASM.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CCS/MSP430X
    ../Libraries/FreeRTOS-Kernel/portable/CCS/MSP430X/: port.c portext.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CODEWARRIOR/COLDFIRE_V1
    ../Libraries/FreeRTOS-Kernel/portable/CodeWarrior/ColdFire_V1/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CODEWARRIOR/COLDFIRE_V2
    ../Libraries/FreeRTOS-Kernel/portable/CodeWarrior/ColdFire_V2/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/CODEWARRIOR/HCS12
    ../Libraries/FreeRTOS-Kernel/portable/CodeWarrior/HCS12/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/COMMON
    ../Libraries/FreeRTOS-Kernel/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM7_AT91FR40008
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM7_AT91FR40008/: port.c portISR.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM7_AT91SAM7S
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM7_AT91SAM7S/: lib_AT91SAM7X256.c port.c portISR.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM7_LPC2000
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM7_LPC2000/: port.c portISR.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM7_LPC23XX
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM7_LPC23xx/: port.c portISR.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_AARCH64
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_AARCH64/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_AARCH64_SRE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_AARCH64_SRE/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CA9
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CA9/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM0
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM0/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM23/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM23/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM23/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM23/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM23_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM23_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM3
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM33/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM33/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM33/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM33/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM33_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM35P/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM35P/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM35P/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM35P/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM35P_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM35P_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM3_MPU
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM3_MPU/: mpu_wrappers_v2_asm.c port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM4_MPU
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM4_MPU/: mpu_wrappers_v2_asm.c port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM55/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM55/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM55/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM55/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM55_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM55_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM7/R0P1
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM85/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM85/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM85/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM85/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CM85_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CM85_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CR5
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CR5/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CRX_MPU
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CRx_MPU/: mpu_wrappers_v2_asm.S port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ARM_CRX_NO_GIC
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ARM_CRx_No_GIC/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/ATMEGA323
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ATMega323/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/AVR32_UC3
    ../Libraries/FreeRTOS-Kernel/portable/GCC/AVR32_UC3/: exception.S port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/COLDFIRE_V2
    ../Libraries/FreeRTOS-Kernel/portable/GCC/ColdFire_V2/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/CORTUS_APS3
    ../Libraries/FreeRTOS-Kernel/portable/GCC/CORTUS_APS3/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/H8S2329
    ../Libraries/FreeRTOS-Kernel/portable/GCC/H8S2329/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/HCS12
    ../Libraries/FreeRTOS-Kernel/portable/GCC/HCS12/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/IA32_FLAT
    ../Libraries/FreeRTOS-Kernel/portable/GCC/IA32_flat/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/MICROBLAZE
    ../Libraries/FreeRTOS-Kernel/portable/GCC/MicroBlaze/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/MICROBLAZEV8
    ../Libraries/FreeRTOS-Kernel/portable/GCC/MicroBlazeV8/: port.c portasm.S port_exceptions.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/MICROBLAZEV9
    ../Libraries/FreeRTOS-Kernel/portable/GCC/MicroBlazeV9/: port.c portasm.S port_exceptions.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/MSP430F449
    ../Libraries/FreeRTOS-Kernel/portable/GCC/MSP430F449/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/NIOSII
    ../Libraries/FreeRTOS-Kernel/portable/GCC/NiosII/: port.c port_asm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/PPC405_XILINX
    ../Libraries/FreeRTOS-Kernel/portable/GCC/PPC405_Xilinx/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/PPC440_XILINX
    ../Libraries/FreeRTOS-Kernel/portable/GCC/PPC440_Xilinx/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RISC-V
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RISC-V/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RL78
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RL78/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RX100
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RX100/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RX200
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RX200/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RX600
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RX600/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RX600V2
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RX600v2/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/RX700V3_DPFPU
    ../Libraries/FreeRTOS-Kernel/portable/GCC/RX700v3_DPFPU/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/STR75X
    ../Libraries/FreeRTOS-Kernel/portable/GCC/STR75x/: port.c portISR.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/GCC/TRICORE_1782
    ../Libraries/FreeRTOS-Kernel/portable/GCC/TriCore_1782/: port.c porttrap.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/78K0R
    ../Libraries/FreeRTOS-Kernel/portable/IAR/78K0R/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CA5_NO_GIC
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CA5_No_GIC/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CA9
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CA9/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM0
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM23/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM23/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM23/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM23/secure/: secure_context.c secure_context_port_asm.s secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM23_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM23_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM3
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM3/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM33/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM33/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM33/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM33/secure/: secure_context.c secure_context_port_asm.s secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM33_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM35P/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM35P/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM35P/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM35P/secure/: secure_context.c secure_context_port_asm.s secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM35P_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM35P_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM4F_MPU
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM4F_MPU/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM55/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM55/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM55/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM55/secure/: secure_context.c secure_context_port_asm.s secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM55_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM55_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM7/R0P1
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM85/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM85/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM85/SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM85/secure/: secure_context.c secure_context_port_asm.s secure_heap.c secure_init.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CM85_NTZ/NON_SECURE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CM85_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ARM_CRX_NO_GIC
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ARM_CRx_No_GIC/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ATMEGA323
    ../Libraries/FreeRTOS-Kernel/portable/IAR/ATMega323/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ATMELSAM7S64
    ../Libraries/FreeRTOS-Kernel/portable/IAR/AtmelSAM7S64/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/ATMELSAM9XE
    ../Libraries/FreeRTOS-Kernel/portable/IAR/AtmelSAM9XE/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/AVR32_UC3
    ../Libraries/FreeRTOS-Kernel/portable/IAR/AVR32_UC3/: port.c read.c write.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/AVR_AVRDX
    ../Libraries/FreeRTOS-Kernel/portable/IAR/AVR_AVRDx/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/AVR_MEGA0
    ../Libraries/FreeRTOS-Kernel/portable/IAR/AVR_Mega0/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/LPC2000
    ../Libraries/FreeRTOS-Kernel/portable/IAR/LPC2000/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/MSP430
    ../Libraries/FreeRTOS-Kernel/portable/IAR/MSP430/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/MSP430X
    ../Libraries/FreeRTOS-Kernel/portable/IAR/MSP430X/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RISC-V
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RISC-V/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RL78
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RL78/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RX100
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RX100/: port.c port_asm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RX600
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RX600/: port.c port_asm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RX700V3_DPFPU
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RX700v3_DPFPU/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/RXV2
    ../Libraries/FreeRTOS-Kernel/portable/IAR/RXv2/: port.c port_asm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/STR71X
    ../Libraries/FreeRTOS-Kernel/portable/IAR/STR71x/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/STR75X
    ../Libraries/FreeRTOS-Kernel/portable/IAR/STR75x/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/STR91X
    ../Libraries/FreeRTOS-Kernel/portable/IAR/STR91x/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/IAR/V850ES
    ../Libraries/FreeRTOS-Kernel/portable/IAR/V850ES/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MEMMANG
    ../Libraries/FreeRTOS-Kernel/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MIKROC/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/MikroC/ARM_CM4F/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MPLAB/PIC18F
    ../Libraries/FreeRTOS-Kernel/portable/MPLAB/PIC18F/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MPLAB/PIC24_DSPIC
    ../Libraries/FreeRTOS-Kernel/portable/MPLAB/PIC24_dsPIC/: port.c portasm_dsPIC.S portasm_PIC24.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MPLAB/PIC32MEC14XX
    ../Libraries/FreeRTOS-Kernel/portable/MPLAB/PIC32MEC14xx/: port.c port_asm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MPLAB/PIC32MX
    ../Libraries/FreeRTOS-Kernel/portable/MPLAB/PIC32MX/: port.c port_asm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MPLAB/PIC32MZ
    ../Libraries/FreeRTOS-Kernel/portable/MPLAB/PIC32MZ/: port.c port_asm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/MSVC-MINGW
    ../Libraries/FreeRTOS-Kernel/portable/MSVC-MingW/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/OWATCOM/16BITDOS/COMMON
    ../Libraries/FreeRTOS-Kernel/portable/oWatcom/16BitDOS/common/: portcomn.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/OWATCOM/16BITDOS/FLSH186
    ../Libraries/FreeRTOS-Kernel/portable/oWatcom/16BitDOS/Flsh186/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/OWATCOM/16BITDOS/PC
    ../Libraries/FreeRTOS-Kernel/portable/oWatcom/16BitDOS/PC/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/PARADIGM/TERN_EE/LARGE_UNTESTED
    ../Libraries/FreeRTOS-Kernel/portable/Paradigm/Tern_EE/large_untested/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/PARADIGM/TERN_EE/SMALL
    ../Libraries/FreeRTOS-Kernel/portable/Paradigm/Tern_EE/small/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/RX100
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/RX100/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/RX200
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/RX200/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/RX600
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/RX600/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/RX600V2
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/RX600v2/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/RX700V3_DPFPU
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/RX700v3_DPFPU/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RENESAS/SH2A_FPU
    ../Libraries/FreeRTOS-Kernel/portable/Renesas/SH2A_FPU/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/ROWLEY/MSP430F449
    ../Libraries/FreeRTOS-Kernel/portable/Rowley/MSP430F449/: port.c portext.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM7_LPC21XX
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CA9
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CA9/: port.c portASM.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CM0
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CM3
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CM4_MPU
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM4_MPU/: mpu_wrappers_v2_asm.c port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/RVDS/ARM_CM7/R0P1
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM7/r0p1/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/SDCC/CYGNAL
    ../Libraries/FreeRTOS-Kernel/portable/SDCC/Cygnal/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/SOFTUNE/MB91460
    ../Libraries/FreeRTOS-Kernel/portable/Softune/MB91460/: port.c __STD_LIB_sbrk.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/SOFTUNE/MB96340
    ../Libraries/FreeRTOS-Kernel/portable/Softune/MB96340/: port.c __STD_LIB_sbrk.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/TASKING/ARM_CM4F
    ../Libraries/FreeRTOS-Kernel/portable/Tasking/ARM_CM4F/: port.c port_asm.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/TEMPLATE
    ../Libraries/FreeRTOS-Kernel/portable/template/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/CDK/T-HEAD_CK802
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/CDK/T-HEAD_CK802/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/COMMUNITY-SUPPORTED-PORTS/CCRH/RH850_F1KM_S4
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Community-Supported-Ports/CCRH/RH850_F1KM_S4/: port.c portasm.s
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/COMMUNITY-SUPPORTED-PORTS/CCS/C2000_C28X
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Community-Supported-Ports/CCS/C2000_C28x/: port.c portasm.asm
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/COMMUNITY-SUPPORTED-PORTS/GCC/MSP430FR5969
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Community-Supported-Ports/GCC/MSP430FR5969/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/COMMUNITY-SUPPORTED-PORTS/GCC/TRICORE_38XA
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Community-Supported-Ports/GCC/TriCore_38xa/: port.c porttrap.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/COMMUNITY-SUPPORTED-PORTS/Z88DK/Z180
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Community-Supported-Ports/Z88DK/Z180/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/ARC_EM_HS
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/ARC_EM_HS/: arc_freertos_exceptions.c arc_support.s freertos_tls.c port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/ARC_V1
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/ARC_v1/: arc_freertos_exceptions.c arc_support.s port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/ARM_TFM
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/ARM_TFM/: os_wrapper_freertos.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/ATMEGA
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/ATmega/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/POSIX
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/Posix/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/POSIX/UTILS
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/Posix/utils/: wait_for_event.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/RP2040
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/RP2040/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/GCC/XTENSA_ESP32
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/GCC/Xtensa_ESP32/: FreeRTOS-openocd.c port.c portasm.S port_common.c port_systick.c xtensa_context.S xtensa_init.c xtensa_loadstore_handler.S xtensa_overlay_os_hook.c xtensa_vectors.S xtensa_vector_defaults.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/PARTNER-SUPPORTED-PORTS/GCC/AVR_AVRDX
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Partner-Supported-Ports/GCC/AVR_AVRDx/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/PARTNER-SUPPORTED-PORTS/GCC/AVR_MEGA0
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Partner-Supported-Ports/GCC/AVR_Mega0/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/PARTNER-SUPPORTED-PORTS/TASKING/AURIX_TC3XX
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Partner-Supported-Ports/Tasking/AURIX_TC3xx/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/PARTNER-SUPPORTED-PORTS/TI/CORTEX_A53_64-BIT_TI_AM64_SMP
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/Partner-Supported-Ports/TI/CORTEX_A53_64-BIT_TI_AM64_SMP/: port.c portASM.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/XCC/XTENSA
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/XCC/Xtensa/: port.c portasm.S portclib.c xtensa_context.S xtensa_init.c xtensa_intr.c xtensa_intr_asm.S xtensa_overlay_os_hook.c xtensa_vectors.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/THIRDPARTY/XCLANG/XCOREAI
    ../Libraries/FreeRTOS-Kernel/portable/ThirdParty/xClang/XCOREAI/: port.c portasm.S
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/WIZC/PIC18
    ../Libraries/FreeRTOS-Kernel/portable/WizC/PIC18/: port.c
  group ../LIBRARIES/FREERTOS-KERNEL/PORTABLE/WIZC/PIC18/DRIVERS/TICK
    ../Libraries/FreeRTOS-Kernel/portable/WizC/PIC18/Drivers/Tick/: isrTick.c Tick.c
software components: CMSIS:CORE 5.0.1
